# Keil uVision project PWM.uvprojx, settings and files
target PWM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\HARDWARE\Median_Filter;..\HARDWARE\5110;..\HARDWARE\TIMER3;..\HARDWARE\Control;..\HARDWARE\NRF24L01
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/Median_Filter/: median_filter.c
    ../HARDWARE/5110/: 5110.c
    ../HARDWARE/TIMER3/: timer3.c
    ../HARDWARE/Control/: control.c
    ../HARDWARE/NRF24L01/: 24l01.c spi.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_spi.c
  group README
    ../: README.TXT
